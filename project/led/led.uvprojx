# Keil uVision project led.uvprojx, settings and files
target led (6190000::V6.19::ARMCLANG)
  device: N32G4FRMEL7 Nationstech
  pack: Nationstech.N32G4FR_DFP.1.0.4
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: led +hex
  c flags: Optim=1 uC99=1 uGnu=1 v6Lang=3 wLevel=4
  c define: N32G4FR, USE_STDPERIPH_DRIVER
  c include: ..\..\CMSIS\core;..\..\CMSIS\device;..\..\n32g4fr_std_periph_driver\inc;..\..\drivers\include\drivers;..\..\drivers\include\ipc;..\..\drivers\include;..\..\DeviceDrivers\i2c\inc;..\..\include;..\..\DeviceDrivers\gpio\inc;..\..\DeviceDrivers\uart\inc;.\user\inc;..\..\lib\rtt-ssd1306\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group startup
    ../../CMSIS/device/startup/: startup_n32g4fr.s
  group user
    ./user/src/: board.c main.c n32g4fr_it.c
  group device_drivers
    ../../DeviceDrivers/uart/src/: drv_usart.c
    ../../DeviceDrivers/gpio/src/: drv_gpio.c
    ../../DeviceDrivers/i2c/src/: drv_i2c.c
  group fwlb
    ../../n32g4fr_std_periph_driver/src/: misc.c n32g4fr_adc.c n32g4fr_bkp.c n32g4fr_can.c n32g4fr_crc.c n32g4fr_dac.c n32g4fr_dbg.c n32g4fr_dma.c n32g4fr_dvp.c n32g4fr_exti.c n32g4fr_flash.c n32g4fr_gpio.c n32g4fr_i2c.c n32g4fr_iwdg.c n32g4fr_pwr.c n32g4fr_qspi.c n32g4fr_rcc.c n32g4fr_rtc.c n32g4fr_sdio.c n32g4fr_spi.c n32g4fr_tim.c n32g4fr_tsc.c n32g4fr_usart.c n32g4fr_wwdg.c
  group rtthread
    ../../rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group cmsis
    ../../CMSIS/device/: system_n32g4fr.c
  group drives
    ../../drivers/misc/: pin.c
    ../../drivers/serial/: serial.c
    ../../drivers/src/: completion.c
    ../../drivers/i2c/: i2c_core.c i2c-bit-ops.c i2c_dev.c
  group cortex-m4
    ../../rt-thread/libcpu/cortex-m4/: cpuport.c context_rvds.S
  group lib
    ../../lib/rtt-ssd1306/src/: ssd1306.c ssd1306_fonts.c
