# Keil uVision project basic_led_blink.uvprojx, settings and files
target N32G4FR (6190000::V6.19::ARMCLANG)
  device: N32G4FRMEL7 Nationstech
  pack: Nationstech.N32G4FR_DFP.1.0.4
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ledBlink +hex
  AfterMake: fromelf --bin --output=Objects./ledBlink.bin Objects./ledBlink.axf
  c flags: Optim=2 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: N32G4FR, USE_STDPERIPH_DRIVER
  c include: ..\01_basic_led_blink;..\..\drivers;..\..\libraries\CMSIS\inc;..\..\libraries\n32g4fr_hal\inc;..\..\rt-thread\include;..\..\rt-thread\include\libc;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\include\ipc;..\..\rt-thread\components\drivers\include\drivers;.\user\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group user
    ./user/src/: board.c main.c n32g4fr_it.c
  group drivers
    ../../drivers/: drv_gpio.c drv_usart.c
  group cmsis
    ../../libraries/CMSIS/src/: system_n32g4fr.c
  group n32g4fr_hal
    ../../libraries/n32g4fr_hal/src/: misc.c n32g4fr_exti.c n32g4fr_rcc.c n32g4fr_sdio.c n32g4fr_gpio.c n32g4fr_usart.c
  group startup
    ../../libraries/startup/: startup_n32g4fr.s
  group cpu
    ../../rt-thread/libcpu/cortex-m4/: context_rvds.S cpuport.c
  group rt-thread
    ../../rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group misc
    ../../rt-thread/components/drivers/misc/: pin.c
    ../../rt-thread/components/drivers/src/: completion.c
    ../../rt-thread/components/drivers/serial/: serial.c
